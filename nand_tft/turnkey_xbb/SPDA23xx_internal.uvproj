# Keil uVision project SPDA23xx_internal.uvproj, settings and files
target SPDA26XX_Nand_TFT (MCS-51)
  device: DS80C323 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(18000000) MODDP2
  output: SPDA23xx +hex
  AfterMake: MAKE_2635_TFT_NAND.bat
  c flags: Optimize=9
  c define: K_ICTYPE = 0x03
  c include: ..\libsource\header
  group ASM
    ../LIBSOURCE/ASM/: STARTUP.A51 L51_BANK.A51 L51_BankingLoader.c
    ../libsource/ASM/: util.a51 lib.a51 dbprintf.a51
  group USB
    ../libsource/USB/: USB.c USB_BULK.c usb_cmds.c USB_EP0.c usbComm.C USB_I2C.c
  group SD
    ../libsource/SD/: SD_CMD.C SD_HW.C
  group Flash
    ../libsource/FLASH/: Flash.C Flash_COMM.C Flash_Init.C FLSHSCAN.C Flash_Read.C Flash_EnHance.C
  group DSP
    ../LIBSOURCE/DSP/: dspphysic.c dspuser.c
  group MAIN
    ./MAIN/: system.C ISR.c St_cmds.c const_timer_init.c init.c variables.c
  group File_Sytem
    ../LIBSOURCE/DOS/: Dos.C dosfat.c dosfdb.c dosfile.c dosinit.c free_cluster.c dosComm.C dos_fileplay.C Memalloc.c
  group Play
    ./Play/: Play_process.C Lyric.c id3.C mcu_dspinit.c FFR1.c
  group Key
    ./Key/: ProcessKey.c
  group UI_USB
    ./UI_USB/: USB_process.c
  group LogData
    ./LogData/: logData.c
  group IR
    ./IR/: remote.c FM.c
  group Host
    ./Host/: Host_command_scsi.c Host_init.c Host_phy.c
  group DIR
    ./DIR/: Dir_process.c Dir_process1.c
  group Menu
    ./Play/: PlayMenu.C
  group LCM
    ./LCM/: Indep_LCM_Func.c TFT_display.c TFT_displayB7.c LCM_driver.c LCM_init.c
  group Jpeg
    ./Jpeg/: Jpeg_process.c
  group Mjpeg
    ./MJpeg/: Mjpeg_process.c
  group Menu_HZK
    ./Menu_hzk/: Menu_hzk1.c Menu_hzk2.c
