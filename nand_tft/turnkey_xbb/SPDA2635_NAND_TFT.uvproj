# Keil uVision project SPDA2635_NAND_TFT.uvproj, settings and files
target SPDA26XX_Nand_TFT (MCS-51)
  device: DS80C323 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(18000000) MODDP2
  output: SPDA23xx +hex
  AfterMake: MAKE_2635_TFT_NAND.bat
  c flags: Optimize=9
  c define: K_ICTYPE = 0x03
  c include: ..\libsource\header
  group ASM
    ../LIBSOURCE/ASM/: STARTUP.A51 L51_BANK.A51 L51_BankingLoader.c
    ../libsource/ASM/: util.a51 lib.a51
  group USB
    ../libsource/USB/: USB.c USB_BULK.c usb_cmds.c USB_EP0.c usbComm.C USB_I2C.c
  group SD
    ../libsource/LIB/: SD_CMD.LIB SD_HW.LIB
  group Flash
    ../libsource/LIB/: FLASH.LIB FLASH_COMM.LIB FLASH_INIT.LIB FLASH_READ.LIB FLSHSCAN.LIB FLASH_ENHANCE.LIB
  group DSP
    ../libsource/LIB/: DSPPHYSIC.LIB DSPUSER.LIB
  group MAIN
    ./MAIN/: system.C ISR.c St_cmds.c const_timer_init.c init.c variables.c
  group File_Sytem
    ../LIBSOURCE/DOS/: Memalloc.c
    ../libsource/LIB/: DOSFILE.LIB DOSFDB.LIB DOSFAT.LIB DOS.LIB DOSINIT.LIB DOSCOMM.LIB DOS_FILEPLAY.LIB FREE_CLUSTER.LIB
  group Play
    ./Play/: Play_process.C Lyric.c id3.C mcu_dspinit.c FFR1.c
  group Key
    ./Key/: ProcessKey.c
  group UI_USB
    ./UI_USB/: USB_process.c
  group LogData
    ./LogData/: logData.c
  group IR
    ./IR/: remote.c FM.c
  group Host
    ../libsource/LIB/: HOST_PHY.LIB HOST_COMMAND_SCSI.LIB HOST_INIT.LIB
  group DIR
    ./DIR/: Dir_process.c Dir_process1.c
  group Menu
    ./Play/: PlayMenu.C
  group LCM
    ./LCM/: Indep_LCM_Func.c TFT_display.c TFT_displayB7.c LCM_init.c LCM_driver.c
  group Jpeg
    ./Jpeg/: Jpeg_process.c
  group Mjpeg
    ./MJpeg/: Mjpeg_process.c
  group Menu_HZK
    ./Menu_hzk/: Menu_hzk1.c Menu_hzk2.c
