# Keil uVision project SPDA2635_NAND_CAR_PSTN.uvproj, settings and files
target SPDA2635-NAND-Car-STN (MCS-51)
  device: DS80C323 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(18000000) MODDP2
  output: SPDA23xx +hex
  AfterMake: Make_2635_Car_NAND.bat
  c flags: Optimize=9
  c define: K_ICTYPE = 0x03
  c include: ..\libsource\header
  group ASM
    ../LIBSOURCE/ASM/: STARTUP.A51 L51_BANK.A51 L51_BankingLoader.c
    ../libsource/ASM/: lib.a51
  group USB
    ../libsource/USB/: USB.c USB_BULK.c usb_cmds.c USB_EP0.c usbComm.C
  group SD
    ../libsource/LIB/: SD_HW.LIB SD_CMD.LIB
  group Flash
    ../libsource/LIB/: FLASH.LIB FLSHSCAN.LIB FLASH_COMM.LIB FLASH_INIT.LIB FLASH_READ.LIB FLASH_ENHANCE.LIB
  group DSP
    ../libsource/LIB/: DSPPHYSIC.LIB DSPUSER.LIB
  group MAIN
    ./MAIN/: system.C ISR.c St_cmds.c const_timer_init.c init.c variables.c
  group File_Sytem
    ../libsource/LIB/: DOS.LIB DOSFAT.LIB DOSFDB.LIB DOSFILE.LIB DOSINIT.LIB FREE_CLUSTER.LIB DOSCOMM.LIB DOS_FILEPLAY.LIB
    ../LIBSOURCE/DOS/: Memalloc.c
  group Play
    ./Play/: Play_process.C Lyric.c id3.C mcu_dspinit.c FFR1.c
  group Key
    ./Key/: ProcessKey.c
  group UI_USB
    ./UI_USB/: USB_process.c
  group LogData
    ./LogData/: logData.c
  group IR
    ./IR/: remote.c FM.c LCM_BMP.c LCM_BMP_driver.c LCM_unicode_hzk.c
  group Host
    ../libsource/LIB/: HOST_INIT.LIB HOST_PHY.LIB HOST_COMMAND_SCSI.LIB
  group DIR
    ./DIR/: Dir_process.c
  group Menu
    ./Play/: PlayMenu.C
    ./Menu_Hzk/: Menu_Hzk.c
  group ui
    ./ui/: ui.c ui_impl.c
