# Keil uVision project SPDA26xx_internal.uvproj, settings and files
target SPDA2635-STN-P-Boombox (MCS-51)
  device: DS80C323 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(18000000) MODDP2
  output: SPDA23xx +hex
  AfterMake: MAKE_2635-STN-P-Boombox.bat
  c flags: Optimize=9
  c define: K_ICTYPE = 0x03
  c include: ..\libsource\header
  group ASM
    ./ASM/: STARTUP.A51 L51_BANK.A51 L51_BankingLoader.c lib.a51 util.a51
  group Calendar
    ./Calendar/: Calendar.c RTC_lunar.c
  group DIR
    ./DIR/: Dir_process.c
  group DOS
    ./DOS/: dosfdb.c dosfile.c dosinit.c dosComm.C dosfat.c dos_fileplay.C DOS_FreeCluster.c dosfile1.c
  group DSP
    ./DSP/: dspphysic.c dspuser.c
  group FM
    ./FM/: FM.c FM_function.c FM_Driver.c
  group Host
    ./Host/: Host_command_scsi.c Host_init.c Host_phy.c
  group IR
    ./IR/: remote.c
  group LCM
    ./LCM/: LCM_Init.c LCM_Display.c LCM_Display1.c LCM_Display2.c LCM_Display3.c LCM_Display4.c LCM_BMP_driver.c LCM_unicode_hzk.c LCM_BMP_data.c
  group LogData
    ./LogData/: logData.c
  group MAIN
    ./MAIN/: System.c System_Comm.c System_Init.c ISR.c variables.c Suspend.c Idle.c RAM_clear.c AlarmClock.c
  group Menu
    ./Menu/: MainMenu.c SetupMenu.c MenuString.c MenuString_Play.c MenuString4.c
  group Play
    ./Play/: Play_process.C Lyric.c id3.C mcu_dspinit.c FF_FR.c
  group RTC
    ./RTC/: RTC_init.c RTC.c
  group SD
    ./SD/: SD_CMD.C SD_HW.C
  group Setup
    ./Setup/: SetClock.c SetBacklight.c SetLanguage.c SetAlarmClock.c SetOFFTimer.c
  group SPI
    ./SPI/: SPI_Flash.C SPI_Init.c
  group USB
    ./USB/: USB.c USB_BULK.c USB_EP0.c usb_cmds.c usbComm.C
  group WAV
    ./WAV/: Play_wav.c Wave_Func.c
  group LineIn
    ./LineIn/: LineIn_Task.c
